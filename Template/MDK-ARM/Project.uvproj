# Keil uVision project Project.uvproj, settings and files
target GD32F130_150 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: GD32F150G8 GigaDevice
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x08000000-0x0800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F130_150
  c include: ..\;..\..\..\..\GD32_Drivers\GD32F1x0_standard_peripheral\Include;..\..\..\..\GD32_Drivers\CMSIS\Include;..\..\Utilities;..\key;..\protocal;..\ring_buf;..\scan;..\..\Template;..\..\Utilities\GD32_EVAL\Common;..\..\Utilities\GD32_EVAL\GD32150R_EVAL;..\flash;..\beep;..\battery;..\..\..\..\GD32_Drivers\GD32F1x0_usbd_driver\Include;..\..\..\..\GD32_Drivers\CMSIS\Device\GD\GD32F1x0\Include;..\..\Common;..\..\BSP;..\..\BSP\lt8920;..\..\Application;..\..\BSP\flash;..\..\BSP\usb
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\output\Project.sct
  group Application
    ../: main.c gd32f1x0_it.c systick.c data_format.c
    ../../Application/: config.c dataParse.c
  group CMSIS
    ../../../../GD32_Drivers/CMSIS/Device/GD/GD32F1x0/Source/: system_gd32f1x0.c
  group Startup
    ../../../../GD32_Drivers/CMSIS/Device/GD/GD32F1x0/Source/ARM/: startup_gd32f1x0.s
  group GD32F1x0_Peripherals
    ../../../../GD32_Drivers/GD32F1x0_standard_peripheral/Source/: gd32f1x0_adc.c gd32f1x0_can.c gd32f1x0_cec.c gd32f1x0_cmp.c gd32f1x0_crc.c gd32f1x0_dac.c gd32f1x0_dbg.c gd32f1x0_dma.c gd32f1x0_exti.c gd32f1x0_fmc.c gd32f1x0_fwdgt.c gd32f1x0_gpio.c gd32f1x0_i2c.c gd32f1x0_ivref.c gd32f1x0_misc.c gd32f1x0_opa.c gd32f1x0_pmu.c gd32f1x0_rcu.c gd32f1x0_rtc.c gd32f1x0_slcd.c gd32f1x0_spi.c gd32f1x0_syscfg.c gd32f1x0_timer.c gd32f1x0_tsi.c gd32f1x0_usart.c gd32f1x0_wwdgt.c
  group USBD_Drivers
    ../../BSP/usb/: hid_core.c
    ../../../../GD32_Drivers/GD32F1x0_usbd_driver/Source/: usbd_core.c usbd_int.c usbd_pwr.c usbd_std.c
  group BSP
    ../../BSP/: BSPWireless.c BSPEeprom.c BSPSystem.c BSPUsb.c BSPKey.c BSPScan.c BSPPlay.c BSPBat.c BSPWatchDog.c
  group DRV
    ../../BSP/lt8920/: lt8920.c
target GD32F170_190 (ARM-ADS)
  device: GD32F150G8 GigaDevice
  cpu: as above
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F170_190
  c include: ..\;..\..\Firmware\Peripherals\inc;..\..\Firmware\CMSIS;..\..\Utilities;..\lt8920;..\ring_buf;..\protocal;..\scan;..\key;..\..\Firmware\GD32_USB_Device_Driver\inc;..\..\Firmware\GD32_USB_Device_Library\Class\hid\inc;..\..\Firmware\GD32_USB_Device_Library\Core\inc;..\..\Utilities\GD32_EVAL\GD32150R_EVAL;..\..\Utilities\GD32_EVAL\Common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
